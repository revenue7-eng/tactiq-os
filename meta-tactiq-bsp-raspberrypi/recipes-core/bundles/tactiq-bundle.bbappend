# Raspberry Pi 4: the bundle carries the compatible string system.conf has on
# this board (rauc-conf.bbappend in this layer).
RAUC_BUNDLE_COMPATIBLE:tactiq-rpi4 = "TactiQ OS RPi4"
