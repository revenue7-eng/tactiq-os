# /etc/fw_env.config is NOT shipped here: tactiq-fw-env (this layer) writes
# it at boot for the medium carrying the root, as on the RK3588 boards.
#
# The full default env is generated by the u-boot-tactiq-rpi recipe
# (do_deploy). This appends the RAUC A/B slot variables on top of it.
# Scoped to tactiq-rpi4, the only machine this layer defines.
do_install:append:tactiq-rpi4() {
    install -d ${D}${sysconfdir}

    install -m 0644 ${DEPLOY_DIR_IMAGE}/u-boot-initial-env ${D}${sysconfdir}/u-boot-initial-env
    cat >> ${D}${sysconfdir}/u-boot-initial-env << 'ENVEOF'
BOOT_ORDER=A B
BOOT_A_LEFT=3
BOOT_B_LEFT=3
ENVEOF
}

do_install[depends] += "u-boot-tactiq-rpi:do_deploy"

FILES:${PN}:append:tactiq-rpi4 = " ${sysconfdir}/u-boot-initial-env"
